Commit message: Add a green platform

File: drone_landing/env/data/platform.urdf (robot description, URDF)
Before this commit: robot simple_box, 1 links, 0 joints
Links:
- link my_box: geometry collision box size=1 1 0.001; visual box size=1 1 0.001
